# Keil uVision project proj_source.uvprojx, settings and files
target NRF52832 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NRF52832 +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NRF52, NRF52832, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\;..\Libraries;..\Libraries\integration\nrfx;..\Libraries\integration\nrfx\legacy;..\Libraries\modules\nrfx;..\Libraries\modules\nrfx\drivers\include;..\Libraries\modules\nrfx\hal;..\Libraries\modules\nrfx\mdk;..\Libraries\components;..\Libraries\components\libraries;..\Libraries\components\drivers_nrf;..\Libraries\components\toolchain\cmsis\include;..\Program;..\..\Proj_vscode\ist_library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Libraries/modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
  group Driver
    ../Program/drivers/: nrf5x_clock.c nrf5x_delay.c nrf5x_flash.c nrf5x_timer.c nrf5x_uart.c nrf5x_i2cSimu.c nrf5x_radio.c
    ../Program/: nrf5x_conf.h
  group Program
    ../Program/: main.c nrf5x_bsp.c nrf5x_bsp.h nrf5x_it.c uart2twi.c boardConfig.h
  group Module
    ../Program/modules/: serial.c kSerial.c
  group Algorithm
    ../Program/algorithms/: mathUnit.c
software components: CMSIS:CORE 5.1.2
